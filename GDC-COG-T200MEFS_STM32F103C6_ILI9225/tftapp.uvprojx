# Keil uVision project tftapp.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tftapp +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD,RGB16BIT
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\user;..\common\hs040tft;..\common\sht1x;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c
  group PeriphDriver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group user
    ./: main.c stm32f10x_it.c ili9225.c julia_set.c
    ./SYSTEM/delay/: delay.c
software components: CMSIS:CORE 5.4.0
